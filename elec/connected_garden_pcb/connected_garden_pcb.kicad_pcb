# Repository guilhembn/connected_garden

## KiCad design elec/connected_garden_pcb/connected_garden_pcb.kicad_pcb

Parts:
C1: 1µF; C_Radial_D6.3mm_H7.0mm_P2.50mm
J1: Moisture1; PinHeader_1x03_P2.54mm_Vertical
J2: Moisture2; PinHeader_1x03_P2.54mm_Vertical
J3: Moisture3; PinHeader_1x03_P2.54mm_Vertical
J4: Moisture4; PinHeader_1x03_P2.54mm_Vertical
J5: Moisture5; PinHeader_1x03_P2.54mm_Vertical
J6: Screw_Terminal_01x02; TerminalBlock_RND_205-00001_1x02_P5.00mm_Horizontal
J7: UART out; PinHeader_1x03_P2.54mm_Vertical
Q1: BUZ11; TO-220-3_Vertical
R1, R2, R3: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 1.8K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 5K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: Reset; SW_TH_Tactile_Omron_B3F-10xx
SW2: Flash; SW_TH_Tactile_Omron_B3F-10xx
U1: TP4056-18650
U2: MCP3208; SOIC-16_3.9x9.9mm_P1.27mm
U3: SPX3819M5-L-3-3; SOT-23-5
U4: DHT11; PinSocket_1x04_P2.54mm_Vertical
U5: ESP-12F; ESP-12E

Connections:
+3V3: C1.1, J1.2, J2.2, J3.2, J4.2, J5.2, R1.1, R3.1, R6.1, U2.15 (Vref), U2.16 (Vdd), U3.5 (OUT), U4.1 (VCC), U5.8 (VCC), U5.17 (GPIO2)
/A0: J1.3, U2.1 (CH0)
/A1: J2.3, U2.2 (CH1)
/A2: J3.3, U2.3 (CH2)
/A3: J4.3, U2.4 (CH3)
/A4: J5.3, U2.5 (CH4)
/A5: R4.2, R5.1, U2.6 (CH5)
/CS: U2.10 (~CS~/SHDN), U5.9 (CS0)
/DHT11Data: R6.2, U4.2 (IO), U5.19 (GPIO4)
/GND_EN: J1.1, J2.1, J3.1, J4.1, J5.1, Q1.2, U4.4 (GND)
/MISO: U2.12 (Dout), U5.10 (MISO)
/MOSG: R7.2, U5.6 (GPIO12)
/MOSI: U2.11 (Din), U5.13 (MOSI)
/RX: J7.1, U5.21 (GPIO3/RXD)
/SCLK: U2.13 (CLK), U5.14 (SCLK)
/TX: J7.2, U5.22 (GPIO1/TXD)
GND: C1.2, J7.3, Q1.3, R2.2, R5.2, R8.2, SW1.1, SW1.3, SW2.2, SW2.4, U1.4 (OUT-), U2.9 (DGND), U2.14 (AGND), U3.2 (GND), U5.15 (GND)
unnamed: J6.1, U1.2 (IN-)
unnamed: J6.2, U1.1 (IN+)
unnamed: Q1.1, R7.1, R8.1
unnamed: R1.2, SW1.2, SW1.4, U5.1 (~RST), U5.3 (EN)
unnamed: R2.1, U5.16 (GPIO15)
unnamed: R3.2, SW2.1, SW2.3, U5.18 (GPIO0)
unnamed: R4.1, U1.3 (OUT+), U3.1 (IN), U3.3 (EN)

Board: 2 copper layers, 24 parts (0 on the bottom side), 24 nets.

## Commit log

2019-07-16 First commit (elec schematic over)
2019-07-24 [Elec] Updates project lib with TP4056-18650
2019-07-24 [Elec] Generates net file
2019-07-24 [Elec] Routes the board
2019-08-20 Changes MCP3208 footprint, reroute and add text
2019-08-20 Generates output gerber files
2019-08-20 Generates PDF output files
2019-08-25 [Elec] Reroutes PCB to v1.2
2019-08-25 [Elec] Outputs board V1.2
2019-08-30 [Elec] Adds BUZ11 to shut sensor off
2019-08-30 [Elec] Routes the new BUZ11
2019-09-15 [code/embedded] Starts code structure
2020-09-04 [Code] Changes monitor and upload speed
2020-09-04 [CPP] Adds vscode file association
2020-09-04 [Code] Deletes communication.h
2020-09-04 [Code] Adds WifiHandler
2020-09-04 [Code] Adds datetime
2020-09-04 [Code] Adds EEPROM manager
2020-09-04 [Code] Adds deep sleep command
2020-09-05 [Code] Adds DHT11 driver
2020-09-05 [Code] Checks if EEPROM is full before saving data
2020-09-05 [Code] Adds humidity to stored data
2020-09-05 [Code] Adds fake credentials for wifi connection
2020-09-05 [Code] Fixes warnings
2020-09-05 [Code] Adds a config file
2020-09-05 [Code] Layouts folders for server
2020-09-05 [Code] Adds server placeholder
2020-09-05 [Code] Adds database creation
2020-09-06 [Code/server] Fixes measurement db request
2020-09-06 [Code/server] Adds install files
2020-09-06 [Code/embed] Adds measurement sending to server
2020-09-06 [Code/server] Adds ESP API
2020-09-06 [Code/server] Adds measurement page
2020-09-09 [Code/embed] Changes eeprom data load/save funcs
2020-09-09 [Code/embed] Adds params
2020-09-09 [Code/embed] Adds current time estimation
2020-09-09 [Code/embed] Adds lastsleep structure
2020-09-09 [Code/embed] Adds no wifi behavior
2020-09-11 [Code/server] Adds estimated timestamp handling
2020-09-11 [Code/embed] Adds estimated timestamp sending
2020-09-21 [Code/embed] Adds NTP retry and failure handling
2020-09-21 [Code/embed] Adds wifi connection retry
2020-09-21 [Code/embed] Adds server response check
2020-09-24 [Code/embed] Changes max stored data
2020-09-24 [Code/embed] Adds anticorruption check on loading
2020-09-24 [Code/embed] Increase default wifi connection retries
2020-09-24 [Code/server] Adds measurement API
2020-09-24 [Code/server] Adds chart plot
2020-09-24 [Code/server] Bumps version
2020-09-25 [Code/server] Adds transparency when timestamp is estimated
2020-09-25 [Code/server] Adds dew point plot
